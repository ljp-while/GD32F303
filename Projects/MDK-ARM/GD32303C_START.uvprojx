# Keil uVision project GD32303C_START.uvprojx, settings and files
target GD32303C_START (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32103B_START +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\..\Projects;..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library\CMSIS;..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Source\ARM;..\..\Hardware\rs485;..\..\Hardware\spi;..\..\Hardware\sca3300;..\..\Hardware\dac;..\..\Hardware\iic;..\..\Hardware\can;..\..\Hardware\time2;..\..\Hardware\ICM-20948
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group CMSIS
    ../: system_gd32f30x.c
  group FWLib
    ../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group hardware
    ../../Hardware/rs485/: rs485.c
    ../../Hardware/sca3300/: sca3300.c
    ../../Hardware/spi/: spi.c
    ../../Hardware/ICM-20948/: icm20948.c
    ../../Hardware/iic/: iic.c
    ../../Hardware/dac/: dac.c
    ../../Hardware/can/: can.c
    ../../Hardware/time2/: time2.c
  group Application
    ../: main.c systick.c gd32f30x_it.c
